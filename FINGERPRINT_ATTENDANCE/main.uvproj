# Keil uVision project main.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(48000000) ELITTLE
  output: main
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER STM32F0XX
  c misc: --c99
  c include: ..\STM32-M0_LIB\stm32f0_stdperiph_lib\STM32F0xx_StdPeriph_Lib_V1.0.0\Libraries\STM32F0xx_StdPeriph_Driver\inc;..\STM32-M0_LIB\stm32f0_stdperiph_lib\STM32F0xx_StdPeriph_Lib_V1.0.0\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\STM32-M0_LIB\stm32f0_stdperiph_lib\STM32F0xx_StdPeriph_Lib_V1.0.0\Libraries\CMSIS\Include;.\USER;..\STM32-M0_LIB\HARDWARE;..\STM32-M0_LIB\SYSTEM;.\CONFIG;..\STM32-M0_LIB\RTT_Implementation_140806\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group SYSTEM
    ../STM32-M0_LIB/stm32f0_stdperiph_lib/STM32F0xx_StdPeriph_Lib_V1.0.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../STM32-M0_LIB/SYSTEM/: gpio.c delay.c usart.c sys_os.c
  group USER
    ./user/: main.c stm32f0xx_it.c stm32f0xx_conf.h
    ./USER/: stm32_config.h
    ../STM32-M0_LIB/SYSTEM/: sys_usart.c
    ./USER/APP/: User_Task_Nrf24l01.c User_Task_Nrf905.c
  group TASK
    ./USER/TASK/: task_led.h
  group HARDWARE
    ../STM32-M0_LIB/HARDWARE/: spi.c exti.c
  group PERIPHERAL
    ../STM32-M0_LIB/PERIPHERAL/NRF905/: NRF905.c
    ../STM32-M0_LIB/PERIPHERAL/NRF24L01/: G32-M0_Nrf24l01.C
  group FWLIB
    ../STM32-M0_LIB/stm32f0_stdperiph_lib/STM32F0xx_StdPeriph_Lib_V1.0.0/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group CORE
    ../STM32-M0_LIB/stm32f0_stdperiph_lib/STM32F0xx_StdPeriph_Lib_V1.0.0/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group JLINK_RTT
    ../STM32-M0_LIB/RTT_Implementation_140806/RTT/: SEGGER_RTT_Printf.c SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h
